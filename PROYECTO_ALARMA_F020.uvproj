# Keil uVision project PROYECTO_ALARMA_F020.uvproj, settings and files
target PROYECTO_ALARMA_F020 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: PROYECTO_ALARMA_F020 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: CODE(0x0100 - 0xef00)
  group INICIALIZACION
    ./: INFOII-09IN.c STARTUP.A51
  group APLICACION
    ./: main.c
  group TECLADO
    ./: TECLADOSW.C TECLADOPR.C TECLADOHW.C TECLADOBUF.C
  group DISPLAY 7 SEG
    ./: DISPLAY7SEGPR.C DISPLAY7SEGHW.C
  group LCD
    ./: dispLCD.c
  group SERIE
    ./: serie.c
  group A/ D
    ./: INFOII-09AD.c
  group TIMERTICK
    ./: TIMERTICK.C INFOII-09tm.c
